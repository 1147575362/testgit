# IAR project realplumLite.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: realplumLite IndieSemi realplumLite
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __CHECK_DEVICE_DEFINES
  ICCARM.CCIncludePath2: inc; drivers; drivers\studio; drivers\core\inc; drivers\hal\inc; drivers\hdf; drivers\hdf\inc; drivers\hdf\sfrs; drivers\hwcfg\inc; drivers\api\inc; Function_Blocks\ColorMixingTask; usr\common; usr\library; usr\leds; lib\downloader\inc; $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CD701_IP6_83212_V005b_3433EPX_app_20231108.bin
  ILINK.IlinkOutputFile: realplumPro_app.out
  ILINK.IlinkIcfFile: realplumLite_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    usr/: main.c
  group applications/config
    usr/common/: appConfig.h
  group applications/include
    usr/common/: applicationTask.h colorCompensationTask.h custom_proto.h isrfuncs.h linMasterTask.h linslaveTask.h linsNodeCfgIdentify.h measureTask.h pdsTask.h Queue.h safetyMonitorTask.h systemInit.h taskManager.h
    Function_Blocks/ColorMixingTask/: colorFormula.h
    usr/library/: colorMixingTask.h linStackTask.h SoftTimerTask.h
    usr/leds/: ledParamTables.h
  group applications/src
    usr/common/: applicationTask.c colorCompensationTask.c custom_proto.c linslaveTask.c linslaveTask_J2602.c linslaveTask_Private.c linsNodeCfgIdentify.c linsNodeCfgIdentify_J2602.c measureTask.c measureTask_multiLeds.c pdsTask.c safetyMonitorTask.c
  group crc/include
    usr/common/: crc32.h
  group crc/src
    usr/common/: crc32.c
  group drivers/core/inc
    drivers/core/inc/: flash_sfrs.h systick_sfrs.h verne.h
  group drivers/core/src
    drivers/core/src/: cstartup_M.c low_level_init.c
  group drivers/hal/inc
    drivers/hal/inc/: adc_device.h atomic.h clock_device.h errno.h flash_device.h gpio_device.h hwProtection.h lin_device.h pmu_device.h pwm_aux_device.h pwm_device.h systick_device.h timer_device.h wdt_device.h
  group drivers/hal/src
    drivers/hal/src/: adc_device.c adc_device_multiLeds.c clock_device.c flash_device.c gpio_device.c hwProtection.c lin_device.c pmu_device.c pwm_aux_device.c pwm_device.c pwm_device_multiLeds.c systick_device.c timer_device.c wdt_device.c
  group drivers/hdf/inc
    drivers/hdf/sfrs/: adc_sfr.h bte_sfr.h buck_trim_sfr.h buckctrl_sfr.h crga_sfr.h evthold_sfr.h flash_sfr.h gpio_sfr.h ioctrla_sfr.h linm_sfr.h lins_sfr.h pmua_sfr.h pwm_aux_sfr.h pwm_sfr.h realplumPro_sfr.h spi_sfr.h sysctrla_sfr.h timer0_sfr.h timer1_sfr.h timer2_sfr.h uart_sfr.h wdt1_sfr.h wdta_sfr.h wica_sfr.h
    drivers/hdf/: realplumPro.h
  group drivers/hwcfg/inc
    drivers/hwcfg/inc/: hwcfg.h
  group drivers/hwcfg/src
    drivers/hwcfg/src/: hwcfg.c
  group library
    usr/library/: ColorMixingTask_RlpmLite.a LinStackTask_RlpmLite.a SoftTimerTask_RlpmLite.a
    Function_Blocks/LedLibrary/: LedParamTables_CoAsia_IWS_E3536_BGR_K3.c LedParamTables_DOMINANT_D6RTB_HKG_CS1124.c LedParamTables_HVRTB-3433EPX_HongLi_20230515.c LedParamTables_osram_gvsr.c LedParamTables_OSRAM_LRTB_GVSG.c LedParamTables_SEOUL_STF0A36ZA_B.c LedParamTables_SpicePlus_3030_S6RTB_THG.c
  group tasks
    usr/common/: systemInit.c taskManager.c
  group validation
    usr/common/: validation.c validation.h
