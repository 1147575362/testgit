<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\realplumLite.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\realplumLite_bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
