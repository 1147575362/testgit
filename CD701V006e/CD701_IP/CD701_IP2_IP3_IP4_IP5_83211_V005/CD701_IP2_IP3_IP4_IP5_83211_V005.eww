<?xml version="1.0" encoding="UTF-8"?>
<workspace>    
<project>
        <path>$WS_DIR$\rugbyPro_app.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\rugbyPro_bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
